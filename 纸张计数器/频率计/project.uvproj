# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: project +hex
  group Source Group 1
    ./: main.c pwm.c pwm.h bmp.h oled.c oled.h oledfont.h
